# Keil uVision project OSC_STM32F429Discovery.uvprojx, settings and files
target OSC_STM32F429Discovery (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: OSC_STM32F429Discovery +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ../Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Include;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ..\ENWIN;      ..\ENWIN\emWin_Config;      ..\ENWIN\emWin_Lib;      ..\HARDWARE;      ..\HARDWARE\LCD_MD050SD;      ..\SOFTWARE;      ..\SOFTWARE\GUI;      ..\Src;      C:\Keil_v5\ARM\ARMCC\include;      ..\ENWIN\inc;      ..\HARDWARE\LCD_ILI9341;      ..\HARDWARE\STM32F429I-Discovery_BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c main.h
    C:/Keil_v5/ARM/ARMCC/include/: stdint.h
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.8.0/Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.8.0/Drivers/CMSIS/Include/: arm_math.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dac_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group ESP_LCD
    ../HARDWARE/LCD_MD050SD/: LCD_MD050SD.c LCD_MD050SD.h LCD_MD050SD_Graph.c LCD_MD050SD_Graph.h LCD_MD050SD_Touch.c LCD_MD050SD_Touch.h
  group BSP_LCD
    ../HARDWARE/LCD_ILI9341/: LCD_ILI9341.c LCD_ILI9341.h LCD_ILI9341_Graph.c LCD_ILI9341_Graph.h LCD_ILI9341_Touch.c LCD_ILI9341_Touch.h
  group HARDWARE
    ../HARDWARE/: ADC.c ADC.h Key.c Key.h mSPI.c mSPI.h sys.c sys.h System.c System.h
  group SOFTWARE
    ../SOFTWARE/: DebugSupport.c DebugSupport.h FFT.c FFT.h FSM.c FSM.h OSC_Work.c OSC_Work.h Usual.c Usual.h
  group ENWIN
    ../ENWIN/emWin_Config/: GUI_X.c GUI_X_Touch_Analog.c GUIConf.c GUIConf.h LCDConf.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h GUIDRV_Template_ESP.c GUIDRV_Template_ESP.h GUIDRV_Template_BSP.c GUIDRV_Template_BSP.h
    ../ENWIN/emWin_Lib/: STemWin528_CM4_Keil.lib
    ../ENWIN/inc/: BUTTON_Private.h
  group GUI
    ../SOFTWARE/GUI/: GUIDefine.h GUIDisp.c GUIDisp.h GUIDraw.c GUIDraw.h GUIUsual.c GUIUsual.h GUINumPad.c GUINumPad.h __UserGUI.c __UserGUI.h
  group STM32F429I-Discovery_BSP
    ../HARDWARE/STM32F429I-Discovery_BSP/: calibration.c stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_ts.c calibration.h io.h stm32f429i_discovery.h stm32f429i_discovery_io.h stm32f429i_discovery_ts.h ts.h
software components: CMSIS:CORE 4.1.0
